# Keil uVision project finalpt1t1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: finalpt1t1
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: FIFO.c FIFO.h joystick.c joystick.h LCD.c LCD.h Main.c os.c os.h osasm.s PLL.c PLL.h PORTE.c PORTE.h startup.s tm4c123gh6pm.h UART.c UART.h UART_FIFO.c UART_FIFO.h prand.h prand.c block.c block.h LED.c LED.h screens.c screens.h buzzer.c buzzer.h
